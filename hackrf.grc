options:
  parameters:
    generate_options: qt_gui
    id: untitled
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: bladerf_gain
  id: variable_qtgui_range
  parameters:
    label: BladeRF Gain
    start: '-1'
    step: '1'
    stop: '60'
    value: '60'
  states: {}
- name: bw
  id: variable_qtgui_range
  parameters:
    label: bw
    start: 1e3
    step: 10e3
    stop: 60e6
    value: 550e3
  states: {}
- name: center_freq
  id: variable_qtgui_range
  parameters:
    label: center_freq
    start: 2.0e9
    step: 1e6
    stop: 6e9
    value: 2.462e9
  states: {}
- name: cycle_period
  id: variable
  parameters:
    value: (dwell_time * (num_antennas + 1))
  states: {}
- name: cycle_samples
  id: variable
  parameters:
    value: cycle_period * samp_rate
  states: {}
- name: dwell_time
  id: variable_qtgui_range
  parameters:
    label: dwell_time
    start: '40e-6'
    step: '1e-6'
    stop: '100e-6'
    value: '50e-6'
  states: {}
- name: enabled
  id: variable_qtgui_check_box
  parameters:
    'false': '1'
    label: enabled
    'true': '0'
    type: int
    value: '0'
  states: {}
- name: num_antennas
  id: variable
  parameters:
    value: '6'
  states: {}
- name: recording
  id: variable_qtgui_check_box
  parameters:
    'false': '1'
    label: recording
    'true': '0'
    type: int
    value: '1'
  states: {}
- name: samp_rate
  id: variable_qtgui_range
  parameters:
    label: samp_rate
    start: 100e3
    step: 1e6
    stop: 40e6
    value: 1e6
  states: {}
- name: sync_threshold
  id: variable_qtgui_range
  parameters:
    label: sync_threshold
    start: '0.0'
    step: '1e-2'
    stop: '1.0'
    value: '0.2'
  states: {}
- name: aoa_chunk_tagger_0
  id: aoa_chunk_tagger
  parameters:
    base_path: '.'
    files_per_folder: '1000'
    samp_rate: samp_rate
    seconds_per_chunk: '1.0'
  states: {}
- name: aoa_chunk_tagger_1
  id: aoa_chunk_tagger
  parameters:
    base_path: /home/noah/droneflight_adam
    files_per_folder: '1000'
    samp_rate: samp_rate
    seconds_per_chunk: '1.0'
  states: {}
- name: bladeRF_source_0
  id: bladeRF_source
  parameters:
    bias_tee0: 'False'
    bias_tee1: 'False'
    buffers: '512'
    buflen: '4096'
    bw: bw
    dac: '10000'
    dc_calibration: LPF_TUNING
    dc_offset_mode0: '0'
    dc_offset_mode1: '0'
    device_id: ''
    feature: default
    fpga_image: /home/noah/hostedxA4.rbf
    fpga_reload: 'False'
    freq: center_freq
    gain0: bladerf_gain
    gain1: '10'
    gain_mode0: 'False'
    gain_mode1: 'False'
    if_gain0: '0'
    if_gain1: '20'
    in_clk: ONBOARD
    iq_balance_mode0: '0'
    iq_balance_mode1: '0'
    lpf_mode: disabled
    metadata: 'False'
    nchan: '1'
    out_clk: 'False'
    ref_clk: 10e6
    sample_format: 16bit
    sample_rate: samp_rate
    sampling: internal
    show_pmic: 'False'
    smb: 38.4e6
    tamer: internal
    trigger0: 'False'
    trigger1: 'False'
    trigger_role0: master
    trigger_role1: master
    trigger_signal0: J51_1
    trigger_signal1: J51_1
    use_dac: 'False'
    use_ref_clk: 'False'
    verbosity: verbose
    xb200: none
  states: {}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0_0_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0_0_0_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_selector_0_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '2'
    output_index: enabled
    type: complex
  states: {}
- name: blocks_selector_0_0_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '2'
    output_index: enabled
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}

connections:
- [aoa_chunk_tagger_0, '0', aoa_chunk_tagger_1, '0']
- [aoa_chunk_tagger_1, '0', blocks_null_sink_0_0_0_0, '0']
- [bladeRF_source_0, '0', blocks_selector_0_0, '0']
- [blocks_selector_0_0, '0', blocks_selector_0_0_0, '0']
- [blocks_selector_0_0, '0', qtgui_sink_x_0, '0']
- [blocks_selector_0_0, '1', blocks_null_sink_0_0, '0']
- [blocks_selector_0_0_0, '0', aoa_chunk_tagger_0, '0']
- [blocks_selector_0_0_0, '1', blocks_null_sink_0_0_0, '0']
- [blocks_throttle2_0, '0', blocks_selector_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0

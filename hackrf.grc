options:
  parameters:
    generate_options: qt_gui
    id: untitled
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: bladerf_gain
  id: variable_qtgui_range
  parameters:
    label: BladeRF Gain
    start: '-1'
    step: '1'
    stop: '60'
    value: '60'
  states: {}
- name: enabled
  id: variable_qtgui_check_box
  parameters:
    'false': '1'
    label: enabled
    'true': '0'
    type: int
    value: '0'
  states: {}
- name: hackrf_amp_on
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    label: hackrf_amp_on
    'true': 'True'
    type: bool
    value: 'False'
  states: {}
- name: recording
  id: variable_qtgui_check_box
  parameters:
    'false': '1'
    label: recording
    'true': '0'
    type: int
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '5000000'
  states: {}
- name: signal_src_freq
  id: variable_qtgui_range
  parameters:
    label: signal_src_freq
    start: 70e6
    step: 1e5
    stop: 2.4e9
    value: 70e6
  states: {}
- name: uhd_bw
  id: variable_qtgui_range
  parameters:
    label: uhd_bw
    start: 1e3
    step: 10e3
    stop: 56e6
    value: 20e6
  states: {}
- name: uhd_center_freq
  id: variable_qtgui_range
  parameters:
    label: uhd_center_freq
    start: 2.0e9
    step: 1e6
    stop: 6e9
    value: 2.462e9
  states: {}
- name: uhd_gain
  id: variable_qtgui_range
  parameters:
    label: UHD Gain
    start: '0'
    step: '1'
    stop: '76'
    value: '76'
  states: {}
- name: uhd_gain_0
  id: variable_qtgui_range
  parameters:
    label: VGA Gain
    start: '0'
    step: '1'
    stop: '62'
    value: '62'
  states: {}
- name: uhd_gain_1
  id: variable_qtgui_range
  parameters:
    label: IF gain
    start: '0'
    step: '1'
    stop: '40'
    value: '40'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 5.840e9
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: aoa_switch_sync_0
  id: aoa_switch_sync
  parameters:
    antenna_offset_deg: '0.0'
    baud_rate: '115200'
    dwell_time: '40e-6'
    max_antennas: '3'
    sample_rate: samp_rate
    serial_port: /dev/ttyUSB0
    settling_time: '5e-6'
    threshold: '0.30'
  states: {}
- name: bladeRF_source_0
  id: bladeRF_source
  parameters:
    bias_tee0: 'False'
    bias_tee1: 'False'
    buffers: '512'
    buflen: '4096'
    bw: uhd_bw
    dac: '10000'
    dc_calibration: LPF_TUNING
    dc_offset_mode0: '0'
    dc_offset_mode1: '0'
    device_id: ''
    feature: default
    fpga_image: /home/noah/hostedxA4.rbf
    fpga_reload: 'False'
    freq: uhd_center_freq
    gain0: '30'
    gain1: '10'
    gain_mode0: 'False'
    gain_mode1: 'False'
    if_gain0: '30'
    if_gain1: '20'
    in_clk: ONBOARD
    iq_balance_mode0: '0'
    iq_balance_mode1: '0'
    lpf_mode: disabled
    metadata: 'False'
    nchan: '1'
    out_clk: 'False'
    ref_clk: 10e6
    sample_format: 16bit
    sample_rate: samp_rate
    sampling: internal
    show_pmic: 'False'
    smb: 38.4e6
    tamer: internal
    trigger0: 'False'
    trigger1: 'False'
    trigger_role0: master
    trigger_role1: master
    trigger_signal0: J51_1
    trigger_signal1: J51_1
    use_dac: 'False'
    use_ref_clk: 'False'
    verbosity: verbose
    xb200: none
  states: {}
- name: blocks_complex_to_arg_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: C:\code_projects\drone test iq data\test.dat
    type: complex
  states: {state: disabled}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '10000'
    max_iter: '4000'
    scale: 1/10000
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: Radians to degrees
    const: '57.29578'
    type: float
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '2'
    output_index: recording
    type: complex
  states: {state: disabled}
- name: blocks_selector_0_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '2'
    output_index: enabled
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: uhd_bw
    fc: uhd_center_freq
    fftsize: '4096'
    name: Sink
    type: complex
    wintype: window.WIN_KAISER
  states: {}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: uhd_bw
    fc: uhd_center_freq
    fftsize: '1024'
    name: Source
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '102400'
    srate: samp_rate
    type: float
    ymax: '180'
    ymin: '-180'
  states: {}
- name: soapy_hackrf_source_0
  id: soapy_hackrf_source
  parameters:
    amp: hackrf_amp_on
    bandwidth: uhd_bw
    center_freq: uhd_center_freq
    gain: uhd_gain_1
    samp_rate: samp_rate
    type: fc32
    vga: uhd_gain_0
  states: {state: disabled}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    bw0: uhd_bw
    center_freq0: uhd_center_freq
    dev_addr: ''
    gain0: uhd_gain
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    bw0: uhd_bw
    center_freq0: uhd_center_freq
    dc_offs_enb0: auto
    dev_addr: ''
    gain0: uhd_gain
    iq_imbal_enb0: auto
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}

connections:
- [aoa_switch_sync_0, '0', blocks_moving_average_xx_0, '0']
- [bladeRF_source_0, '0', blocks_selector_0, '0']
- [bladeRF_source_0, '0', blocks_selector_0_0, '0']
- [blocks_complex_to_arg_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_moving_average_xx_0, '0', blocks_complex_to_arg_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_selector_0, '0', blocks_file_sink_0, '0']
- [blocks_selector_0, '1', blocks_null_sink_0, '0']
- [blocks_selector_0_0, '0', aoa_switch_sync_0, '0']
- [blocks_selector_0_0, '0', qtgui_sink_x_0, '0']
- [blocks_selector_0_0, '1', blocks_null_sink_0_0, '0']
- [blocks_throttle2_0, '0', qtgui_sink_x_0_0, '0']
- [blocks_throttle2_0, '0', uhd_usrp_sink_0, '0']
- [soapy_hackrf_source_0, '0', blocks_selector_0, '0']
- [soapy_hackrf_source_0, '0', blocks_selector_0_0, '0']
- [uhd_usrp_source_0, '0', blocks_selector_0, '0']
- [uhd_usrp_source_0, '0', blocks_selector_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
